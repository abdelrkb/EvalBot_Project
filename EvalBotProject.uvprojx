# Keil uVision project EvalBotProject.uvprojx, settings and files
target Exo2 (6230000::V6.23::ARMCLANG)
  device: LM3S1968 Texas Instruments
  pack: Keil.LM3S_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: EvalBotProject
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: Exo2.s
software components: Device:Startup 1.0.0
