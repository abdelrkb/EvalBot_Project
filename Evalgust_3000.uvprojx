# Keil uVision project Evalgust_3000.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: LM3S1968 Texas Instruments
  pack: Keil.LM3S_DFP.1.1.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Evalgust_3000
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: RK_Config_Moteur.s RK_PriseEnMain_Moteurs.s RK_Config_IO.s RK_Memory.s
software components: Device:Startup 1.0.0
